# Keil uVision project LCD1602Clock.uvprojx, settings and files
target LCD1602 Clock (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f10x +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,EN_USART1_RX,DELAY_WITH_SYSTICK
  c include: ..\Library\CMSIS;..\Library\StdPeriph_Driver\inc;..\Hardware\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./src/: main.c
    ./inc/: stm32f10x_conf.h
  group Public
    ./src/: nvic.c delay.c usart.c gpio.c debug.c rtc.c exti.c
  group Hardware
    ../Hardware/src/: lcd1602a.c buzzer.c
  group StdPeriph_Driver
    ../Library/StdPeriph_Driver/src/: stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c misc.c
  group CMSIS
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Library/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group Docs
    ../: Readme.md
